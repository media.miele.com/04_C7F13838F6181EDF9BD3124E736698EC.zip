Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: ee6ef82c-a911-423d-88f2-05a44d9e54fd, NumberOfSaves: 1]
File name: 0001
Time: 2024-09-02T07:58:47+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12568520_F_DAC2240_EDST:28C2240S_F_12568520_DAC2240_EDST, (2)
In: Default
Type - Material: z_Miele_Design_CLST, <Unnamed>, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 1165 mm; Height: 196 mm; Depth: 500 mm
Pset_BuildingElementProxyCommon - Reference: 28C2240S_F_12568520_DAC2240_EDST; sets with these values: 2
